# Keil uVision project Project_1656.uvproj, settings and files
target HT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F1656 Holtek
  cpu: IROM(0x00000000-0x0003FBFF) IRAM(0x20000000-0x20007FFF) CPUTYPE("Cortex-M3") CLOCK(8000000)
  output: HT32 +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F1656_DVB, USE_HT32F1655_56, USE_MEM_HT32F1656
  c include: ..\;..\library\HT32F1xxxx_Driver\inc;..\library\CMSIS\Include;..\library\Device\Holtek\HT32F1xxxx\Include;..\library\HT32_USBD_Library\inc;..\utilities;..\application\user;..\application\Ultrasonic;..\application\Steering;..\ucosiii\APP;..\ucosiii\BSP;..\ucosiii\BSP\led;..\ucosiii\uC-CPU\ARM-Cortex-M3\RealView;..\ucosiii\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\ucosiii\uCOS-III\Source;..\ucosiii\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\ucosiii\uC-CPU;..\ucosiii\uC-LIB
  asm define: USE_HT32_CHIP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Library
    ../library/HT32F1xxxx_Driver/src/: ht32_cm3_misc.c ht32f1xxxx_adc.c ht32f1xxxx_bftm.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp_op.c ht32f1xxxx_crc.c ht32f1xxxx_ebi.c ht32f1xxxx_exti.c ht32f1xxxx_flash.c ht32f1xxxx_gpio.c ht32f1xxxx_i2c.c ht32f1xxxx_i2s.c ht32f1xxxx_mctm.c ht32f1xxxx_pdma.c ht32f1xxxx_pwrcu.c ht32f1xxxx_rstcu.c ht32f1xxxx_rtc.c ht32f1xxxx_sci.c ht32f1xxxx_spi.c ht32f1xxxx_tm.c ht32f1xxxx_usart.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c
  group Config
    ./: ht32_op.s HT32F1xxxx_01_DebugSupport.ini
    ../application/user/: ht32f1xxxx_conf.h
  group CMSIS
    ../library/Device/Holtek/HT32F1xxxx/Source/: system_ht32f1xxxx_01.c
  group MDK-ARM
    ../library/: startup_ht32f1xxxx_01.s
  group USBD_Library
    ../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Retarget
    ../library/HT32F1xxxx_Driver/src/: ht32_serial.c ht32_retarget.c
  group Utilities
    ../utilities/common/: i2c_eeprom.c spi_flash.c
    ../utilities/: ht32_board.c
  group User
    ../application/user/: ht32f1xxxx_01_it.c
  group Doc
    ../: readme.txt
  group APP
    ../ucosiii/APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../ucosiii/BSP/: bsp.c bsp.h
    ../ucosiii/BSP/led/: bsp_led.c
  group UC/CPU
    ../ucosiii/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../ucosiii/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group UC/LIB
    ../ucosiii/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../ucosiii/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UC/OS_III_SOURCE
    ../ucosiii/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UC/OS_III_PORT
    ../ucosiii/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
